# IAR project UART1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S001J3 STM8S001J3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S001
  ICCSTM8.CCIncludePath2: Bsp; StdPeriph_Driver\inc; User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: UART1.hex
  ILINK.IlinkOutputFile: UART1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: 例程说明.txt
  group Bsp
    Bsp/: uart1.c
  group StdPeriph_Driver
    StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim1.c stm8s_uart1.c
  group User
    User/: main.c stm8s_it.c
